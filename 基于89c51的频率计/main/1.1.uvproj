# Keil uVision project 1.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: freCountMain.c led.c target.c Include.h led.h target.h
